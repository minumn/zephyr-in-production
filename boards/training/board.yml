## boards/training/board.yml
```yaml
board:
  name: training
  full_name: Training Board
  vendor: nxp
  socs:
  - name: mcxa156
```
